File: Bank-d.kicad_sch (KiCad schematic)
At the start: 7 parts, among them U1 XC7K325T-FFG676

Commit message: WIP
WIP - save current state
Parts:
- renumbered C97 to C12, C98 to C13, L15 to L2
