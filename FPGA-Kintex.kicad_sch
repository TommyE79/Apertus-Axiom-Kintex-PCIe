File: FPGA-Kintex.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: WIP
WIP - save current state
Other:
- sheet Bank-G renamed JTAG(BANK-G)
